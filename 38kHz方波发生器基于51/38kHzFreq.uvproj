# Keil uVision project 38kHzFreq.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12LE5A60S2 STC12LE5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 38kHzFreq +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./APP/: Source.c
