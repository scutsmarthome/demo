# Keil uVision project STM-DEMO.uvproj, settings and files
target STM32-DEMO (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM-DEMO +hex
  c flags: Optim=1
  c define: USER_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS;..\FWLIB\inc;..\FWLIB\src;..\USER;..\APP;..\APP\DELAY;..\APP\USART;..\APP\ENC28J60;..\APP\TCP_IP_UTP;..\APP\WebServer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_usart.c
  group STARTCODE
    ../CMSIS/startup/: STM32F10x.s
  group USER
    ../USER/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group DELAY
    ../APP/DELAY/: SYSTICK.C
  group USART
    ../APP/USART/: USART.C
  group ENC28J60
    ../APP/ENC28J60/: enc28j60.c spi_enc28j60.c enc28j60.h spi_enc28j60.h
  group TCP_IP_UDP
    ../APP/TCP_IP_UTP/: ip_arp_udp_tcp.c ip_arp_udp_tcp.h net.h
  group WEB_SERV
    ../APP/WebServer/: web_server.c web_server.h
